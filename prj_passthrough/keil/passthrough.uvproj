# Keil uVision project passthrough.uvproj, settings and files
target passthrough (ARM-ADS)
  device: QN9020 Quintic
  cpu: IRAM(0x00008000-0x0000FFFF) IROM(0x00000000-0x00007FFF) CLOCK(16000000) CPUTYPE("Cortex-M0")
  output: passthrough
  AfterMake: fromelf --bin --output ./bin/passthrough.bin ./obj/passthrough.axf
  c flags: Optim=1 OneElfS=1
  c misc: --C99
  c include: ..\..\src\fw;..\..\src\profiles;..\..\src\profiles\prox\proxr;..\..\src\app;..\..\src\app\gap;..\..\src\app\gatt;..\..\src\app\smp;..\..\src\app\proxr;..\..\src\cmsis;..\..\src\driver;..\..\src\lib;..\..\src\qnevb;..\src;..\..\src\profiles\qpp;..\..\src\profiles\qpp\qppc;..\..\src\profiles\qpp\qpps;..\..\src\app\qppc;..\..\src\app\qpps;..\..\src\profiles\ota
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x8000 size 0x8000
  scatter file: ..\..\src\link\keil\qn9020_link.sct
  link misc: --no_autoat --remove
  group startup
    ../../src/startup/keil/: startup.s
  group main
    ../../src/main/: app_main.c
  group usr
    ../src/: system.c usr_design.c app_pt.c app_pt_gpio.c
  group app
    ../../src/app/: app_util.c app_env.c app_printf.c app_sys.c app_task.c
    ../../src/app/gap/: app_gap.c app_gap_task.c
    ../../src/app/gatt/: app_gatt.c app_gatt_task.c
    ../../src/app/smp/: app_smp.c app_smp_task.c
    ../../src/app/qpps/: app_qpps.c app_qpps_task.c
  group profiles
    ../../src/profiles/: prf_utils.c
    ../../src/profiles/qpp/qpps/: qpps.c qpps_task.c
    ../../src/profiles/ota/: flash_lib.c otas.c otas_task.c
  group drivers
    ../../src/driver/: uart.c gpio.c sleep.c syscon.c pwm.c wdt.c timer.c rtc.c dma.c serialflash.c
  group lib
    ../../src/lib/keil/: qn9020b2_lib_peripheral.lib
  group qnevb
    ../../src/qnevb/: led.c button.c buzz.c
  group retarget
    ../../src/retarget/: retarget.c
